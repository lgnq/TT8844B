# Keil uVision project TT8844B.uvproj, settings and files
target TT8844B (MCS-51)
  device: C8051F384 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x0FFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: TT8844B +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\include
  group startup
    ./: STARTUP.A51
  group main
    ./main/: main.c
  group system
    ./system/: system.c
  group tasks
    ./tasks/: heartbeat.c watchdog.c key.c
  group scheduler
    ./scheduler/: ttc_sch_od.c
  group bsp
    ./bsp/: uart.c bsp.c tw884x.c i2c.c font.c guide_line.c
